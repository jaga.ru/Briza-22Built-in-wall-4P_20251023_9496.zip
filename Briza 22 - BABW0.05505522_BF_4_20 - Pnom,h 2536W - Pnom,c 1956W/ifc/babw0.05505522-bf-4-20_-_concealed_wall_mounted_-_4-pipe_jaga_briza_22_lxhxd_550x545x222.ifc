Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-01-15T14:54:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - IFC Model Exchange with ARCHICAD 22.0.0.4018
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 15 14:54:35 2020 * Host: DESKTOP-SDDTMPI * Database: C:\Users\BMP_02\AppData\Local\Temp\{C185963E-CD57-45C1-BBA0-BB9673E32BC5}\ifc * Database version: 5507 * Database creation date: Wed Jan 15 14:54:35 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 15 14:54:35 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 15 14:54:35 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcEnergyConversionDevice: babw0.05505522/bf/4/20 - concealed wall mounted - 4-pipe_jaga_briza 22_lxhxd 550x545x222, RSen_55_ME_FB_fan coils ducted - 4 pipes_jaga:babw0.05505522/bf/4/20 - concealed wall mounted - 4-pipe_jaga_briza 22_lxhxd 550x545x222:317825
In: Level 1
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: RSen_x_rgb 192 192 192 T00 gray_gen, RSen_x_rgb 000 000 000 T00 black_gen
Type - Constraints - Default Elevation: 100 mm
Type - Construction - RSen_C_diameter_type: OD; RSen_C_diameter_type_index: 1; TBQen_C_SOg_01: standard; TBQen_C_SOg_02: none_gen
Type - Dimensions - RSen_C_depth: 222 mm; RSen_C_height: 545 mm; RSen_C_length: 550 mm
Type - Electrical - RSen_E_c01_apparent_power: 42 W; RSen_E_c01_current: 0 A; RSen_E_c01_division_engine: yes; RSen_E_c01_load_class: Other; RSen_E_c01_number_of_poles: 1; RSen_E_c01_power: 42 W; RSen_E_c01_power_factor: 1; RSen_E_c01_voltage: 230 V
Type - Energy Analysis - TBQen_M_cooling_output_for_16_18_27_0: 7717.72; TBQen_M_cooling_output_for_16_18_27_1: 12561.5; TBQen_M_cooling_output_for_16_18_27_2: 17060.8; TBQen_M_cooling_output_for_16_18_27_3: 21054.2; TBQen_M_cooling_output_for_16_18_27_4: 23368.4; TBQen_M_heat_output_for_75_65_20_0: 14649.7; TBQen_M_heat_output_for_75_65_20_1: 19482.7; TBQen_M_heat_output_for_75_65_20_2: 24574; TBQen_M_heat_output_for_75_65_20_3: 27297.3; TBQen_M_heat_output_for_75_65_20_4: 29224
Type - Identity Data - Description: jaga_briza 22_concealed wall mounted; Manufacturer: Jaga; Model: Briza 22; RSen_C_code_article: BABW0.05505522/BF/4/20; RSen_C_code_ETIM: Air-conditioning split system – inside unit (evaporator); RSen_C_code_ETIM_URL: https://prod.etim-international.com/Class/Details?classId=EC011580&classVersion=4; RSen_C_code_product: FWM03DAF; RSen_C_code_product_class: FWM-DAF; RSen_C_content_creator: © ThorbiQ; RSen_C_content_date_changed: 03/12/2019; RSen_C_content_date_issue: 03/12/2019; RSen_C_content_provider: Jaga; RSen_C_content_version: 1.1.0; RSen_C_description: jaga_briza 22_concealed wall mounted; RSen_C_IFC_version: 2x3; RSen_C_license: Creative Commons Attribution NoDerivs (CC-ND); RSen_C_license_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; RSen_C_model: Briza 22; RSen_C_revit_version: 2017; RSen_C_type: 4-pipe; RSen_C_type_comments: concealed wall mounted; TBQ_I BaseKeynote: 55.10.10.10; Type Name: babw0.05505522/bf/4/20 - concealed wall mounted - 4-pipe_jaga_briza 22_lxhxd 550x545x222; URL: www.jaga.com
Type - Materials and Finishes - RSen_C_material: RSen_x_rgb 192 192 192 T00 gray_gen; TBQ_I Colour: -; TBQ_I Colour chart: -
Type - Mechanical - RSen_P_c03_volume_flow: 0 m3/s; RSen_P_c04_volume_flow: 0 m3/s; RSen_P_c05_load_value: 0; TBQ_I Air flow rate_high: 0 m3/s; TBQ_I Air flow rate_low: 0 m3/s; TBQ_I Air flow rate_nom: 4.75767 m3/s
Type - Model Properties - TBQ_I Depth_cm: 22; TBQ_I Height_cm: 55; TBQ_I Length_cm: 55; TBQ_I Suspension_max: 10 mm; TBQ_I Suspension_min: 0 mm
Type - Other - Category: Mechanical Equipment; Family Name: RSen_55_ME_FB_fan coils ducted - 4 pipes_jaga; RSen_E_c01_description: c01_el; RSen_E_c01_power_factor_state: Lagging; RSen_E_c01_system_type: Power - Balanced; RSen_E_c01_yes_no: yes; RSen_E_c02_description: c02_controls; RSen_E_c02_yes_no: yes; RSen_M_c01_description: c01_return air; RSen_M_c01_diameter: 0 mm; RSen_M_c01_flow_configuration: Preset; RSen_M_c01_flow_direction: in; RSen_M_c01_height: 190 mm; RSen_M_c01_loss_method: Not Defined; RSen_M_c01_optional: no; RSen_M_c01_shape: Rectangular; RSen_M_c01_system_classification: Return Air; RSen_M_c01_width: 500 mm; RSen_M_c01_yes_no: yes; RSen_M_c02_description: c02_supply air; RSen_M_c02_diameter: 0 mm; RSen_M_c02_flow_configuration: Preset; RSen_M_c02_flow_direction: Out; RSen_M_c02_height: 170 mm; RSen_M_c02_loss_method: Not Defined; RSen_M_c02_optional: no; RSen_M_c02_shape: Rectangular; RSen_M_c02_system_classification: Supply Air; RSen_M_c02_width: 500 mm; RSen_M_c02_yes_no: yes; RSen_P_c01_description: c01_supply hydraulic connection; RSen_P_c01_diameter: 20 mm; RSen_P_c01_diameter_calc: 20 mm; RSen_P_c01_flow_configuration: Preset; RSen_P_c01_flow_direction: In; RSen_P_c01_loss_method: Not Defined; RSen_P_c01_system_classification: Hydronic Supply; RSen_P_c01_yes_no: yes; RSen_P_c02_description: c02_return hydraulic connection; RSen_P_c02_diameter: 20 mm; RSen_P_c02_diameter_calc: 20 mm; RSen_P_c02_flow_configuration: Preset; RSen_P_c02_flow_direction: Out; RSen_P_c02_loss_method: Not Defined; RSen_P_c02_system_classification: Hydronic Return; RSen_P_c02_yes_no: yes; RSen_P_c03_description: c03_supply hydraulic connection; RSen_P_c03_diameter: 15 mm; RSen_P_c03_diameter_calc: 15 mm; RSen_P_c03_flow_configuration: Preset; RSen_P_c03_flow_direction: In; RSen_P_c03_loss_method: Not Defined; RSen_P_c03_system_classification: Hydronic Supply; RSen_P_c03_yes_no: yes; RSen_P_c04_description: c04_return hydraulic connection; RSen_P_c04_diameter: 15 mm; RSen_P_c04_diameter_calc: 15 mm; RSen_P_c04_flow_configuration: Preset; RSen_P_c04_flow_direction: Out; RSen_P_c04_loss_method: Not Defined; RSen_P_c04_system_classification: Hydronic Return; RSen_P_c04_yes_no: yes; RSen_P_c05_description: c05_drain piping connection; RSen_P_c05_diameter: 20 mm; RSen_P_c05_diameter_calc: 20 mm; RSen_P_c05_flow_configuration: Fixture Units; RSen_P_c05_flow_direction: Out; RSen_P_c05_loss_method: Not Defined; RSen_P_c05_system_classification: Sanitary; RSen_P_c05_yes_no: yes
Pset_ManufacturerTypeInformation - Manufacturer: Jaga
Pset_DistributionFlowElementCommon - Reference: RSen_55_ME_FB_fan coils ducted - 4 pipes_jaga:babw0.05505522/bf/4/20 - concealed wall mounted - 4-pipe_jaga_briza 22_lxhxd 550x545x222
Constraints - Elevation: 0 mm; Host: Reference Plane : v_rightleft
Construction - RSen_C_accessory_ME_01: none_gen; RSen_C_alignment: Center; RSen_C_alignment_index: 0; RSen_C_connection_set_CHr: none; RSen_C_connection_set_CHs: none; RSen_C_suspension_height: 0 mm; TBQen_C_GOg: no; TBQen_C_SOg: yes
Dimensions - Area: 15.0892 m2; Volume: 1.82363 m3
Energy Analysis - TBQen_M_cooling_output_for_16_18_27: 7717.72; TBQen_M_current_cooling_output_for_applied_regime: 0; TBQen_M_current_cooling_output_for_applied_regime_index: 0; TBQen_M_current_cooling_output_for_applied_regime_info: 2V; TBQen_M_current_heat_output_for_applied_regime: 0; TBQen_M_current_heat_output_for_applied_regime_index: 0; TBQen_M_current_heat_output_for_applied_regime_info: 2V; TBQen_M_heat_output_for_75_65_20: 14649.7; TBQen_M_max_cooling_output_for_applied_regime: 7717.72; TBQen_M_max_heat_output_for_applied_regime: 14649.7; TBQen_M_temperature_cooling: 27 kg/K/s3; TBQen_M_temperature_cooling_return: 18 kg/K/s3; TBQen_M_temperature_cooling_supply: 16 kg/K/s3; TBQen_M_temperature_heating: 20 kg/K/s3; TBQen_M_temperature_heating_return: 65 kg/K/s3; TBQen_M_temperature_heating_supply: 75 kg/K/s3
Graphics - RSen_C_clearance_zone: no; RSen_C_connection_zone: no; RSen_C_maintenance_zone: no; RSen_C_neighbour_unit: no; RSen_C_neighbour_unit_displacement_back: 0 mm; RSen_C_neighbour_unit_displacement_front: 0 mm; RSen_C_neighbour_unit_displacement_left: 0 mm; RSen_C_neighbour_unit_displacement_right: 0 mm; TBQen_C_logo: yes
Identity Data - Mark: 164
Mechanical - RSen_M_c01_flow_rate: 4.75767 m3/s; RSen_M_c02_flow_rate: 4.75767 m3/s; RSen_P_c01_volume_flow: 0.0010757 m3/s; RSen_P_c02_volume_flow: 0.0010757 m3/s; System Classification: Power,Controls,Sanitary,Hydronic Supply,Hydronic Return,Return Air,Supply Air
Mechanical - Flow - RSen_M_air_flow_rate: Norm.; RSen_M_air_flow_rate_index: 1; RSen_M_flow_rate: 4.75767 m3/s
Other - Family: RSen_55_ME_FB_fan coils ducted - 4 pipes_jaga: babw0.05505522/bf/4/20 - concealed wall mounted - 4-pipe_jaga_briza 22_lxhxd 550x545x222; Family and Type: RSen_55_ME_FB_fan coils ducted - 4 pipes_jaga: babw0.05505522/bf/4/20 - concealed wall mounted - 4-pipe_jaga_briza 22_lxhxd 550x545x222; RSen_P_c01_temperature: 75 kg/K/s3; RSen_P_c02_temperature: 65 kg/K/s3; RSen_P_c03_temperature: 16 kg/K/s3; RSen_P_c04_temperature: 18 kg/K/s3; Type: RSen_55_ME_FB_fan coils ducted - 4 pipes_jaga: babw0.05505522/bf/4/20 - concealed wall mounted - 4-pipe_jaga_briza 22_lxhxd 550x545x222; Type Id: RSen_55_ME_FB_fan coils ducted - 4 pipes_jaga: babw0.05505522/bf/4/20 - concealed wall mounted - 4-pipe_jaga_briza 22_lxhxd 550x545x222
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: https://thorbiq.freshdesk.com/support/home
